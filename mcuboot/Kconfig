## mcuboot/Kconfig
```kconfig
# MCUboot Kconfig entry point
source "${ZEPHYR_MCUBOOT_MODULE_DIR}/boot/zephyr/Kconfig"
```
